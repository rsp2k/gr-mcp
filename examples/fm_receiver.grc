options:
  parameters:
    description: FM receiver template for fm_scanner.py
    generate_options: no_gui
    id: fm_receiver
    output_language: python
    run_options: run
    title: FM Receiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 102.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '5'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.4e6
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8090'
  states: {}

connections:
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
