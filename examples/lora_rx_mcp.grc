options:
  parameters:
    author: gr-mcp
    description: 'LoRa receiver built entirely through MCP tools. Matches Heltec V3 beacon: 915MHz, SF7, BW125k.'
    generate_options: no_gui
    id: lora_rx_mcp
    output_language: python
    title: LoRa SDR Receiver (MCP-built)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: lora_bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: lora_sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: lora_bw
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: int(samp_rate/2)
    sf: lora_sf
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [lora_rx_0, out, blocks_message_debug_0, print]
- [low_pass_filter_0, '0', lora_rx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
