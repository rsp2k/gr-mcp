options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 101.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480e3
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '5'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: 101.1e6
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 2.4e6
    sync: sync
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 0.0.0.0
    port: '8090'
  states: {}

connections:
- [analog_wfm_rcv_1, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_1, '0']
- [osmosdr_source_1, '0', low_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
